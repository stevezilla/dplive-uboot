## configs/mx6amherstsolo_defconfig
```kconfig
CONFIG_SYS_EXTRA_OPTIONS="IMX_CONFIG=board/freescale/mx6amherstsolo/imximage.cfg,MX6Q"
CONFIG_ARM=y
CONFIG_TARGET_MX6AMHERSTSOLO=y
```
